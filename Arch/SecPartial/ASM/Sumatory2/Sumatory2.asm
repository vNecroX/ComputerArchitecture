.DEFINE
	NUMAA0 01H	
	NUMAA1 02H
	NUMAA2 03H
	NUMAA3 04H

	NUMXX	03H

.ORG 0100H
	MVI A, NUMAA0
	STA 0000H		;STORES NUMAA0 IN DIR 0000H = 01H

	MVI A, NUMAA1
	STA 0001H		;STORES NUMAA1 IN DIR 0001H = 02H

	MVI A, NUMAA2
	STA 0002H		;STORES NUMAA2 IN DIR 0002H = 03H

	MVI A, NUMAA3
	STA 0003H		;STORES NUMAA3 IN DIR 0003H = 04H

	CALL ARITH
	HLT

;- - - - - - - - - - - - - - - - - - - - - - - - - - - - - - - - - - - - - - - -

ARITH:
	CALL ZERO
	CALL ONE
	CALL TWO
	CALL THREE
	CALL SUMATORY2

;- - - - - - - - - - - - - - - - - - - - - - - - - - - - - - - - - - - - - - - -

ZERO:
				;ANY NUM^0 = 01H 

	MVI A, 01H		;LOAD STORED DATA IN DIR 0000H IN REC A = 01H
	STA 0040H		;STORES FIRST TERM IN DIR 0040H = 01H	
	RET

ONE:
	MVI A, NUMXX	;ANY NUM^1 = NUM
	MOV C, A		;C = 03H, POW (MUL), DCR

	LDA 0001H		;LOAD STORED DATA IN DIR 0001H IN REC A = 02H
	MOV B, A		;B = 02H, ADD
	
	MVI A, 00H
	CALL TIMES

	STA 0041H		;STORES SECOND TERM IN DIR 0041H = 06H
	RET

TWO:
	MVI A, NUMXX	
	MOV B, A
	MOV C, A		;ANY NUM^2 = ADD THE SAME NUM, NUM TIMES
	
	MVI A, 00H
	CALL TIMES 

	STA 0022H		;STORES THIRD POW IN DIR 0022H = 09H
	MOV C, A		;C = 09H, POW (MUL), DCR

	LDA 0002H		;LOAD STORED DATA IN DIR 0002H IN REC A = 03H
	MOV B, A		;B = 03H, ADD

	MVI A, 00H
	CALL TIMES

	STA 0042H		;STORES THIRD TERM IN DIR 0042H = 1BH
	RET

THREE:
	MVI A, NUMXX	
	MOV B, A

	LDA 0022H		;LOAD STORED DATA IN DIR 0022H IN REC A = 09H
	MOV C, A		;C = 09H, POW (MUL), DCR

	MVI A, 00H
	CALL TIMES

	STA 0023H		;STORES FOURTH POW IN DIR 0023H = 27H
	MOV C, A		;C = 27H, POW (MUL), DCR

	LDA 0003H		;LOAD STORED DATA IN DIR 0003H IN REC A = 04H
	MOV B, A		;B = 04H, ADD

	MVI A, 00H
	CALL TIMES

	STA 0043H 		;STORES FOURTH TERM IN DIR 0043H = 6CH
	RET

SUMATORY2:
	LDA 0040H		;LOAD STORED DATA IN DIR 0040H IN REC A = 01H, FIRST TERM
	MOV B, A		;B = 01H
	
	LDA 0041H		;LOAD STORED DATA IN DIR 0041H IN REC A = 06H, SECOND TERM
	MOV C, A		;C = 06H

	LDA 0042H 		;LOAD STORED DATA IN DIR 0042H IN REC A = 1BH (27D), THIRD TERM
	MOV D, A		;D = 1BH

	LDA 0043H 		;LOAD STORED DATA IN DIR 0043H IN REC A = 6CH (108D), FOURTH TERM
	MOV E, A		;E = 6CH

	MVI A, 00H

	ADD B
	ADD C
	ADD D
	ADD E
	MOV H, A
	RET

;- - - - - - - - - - - - - - - - - - - - - - - - - - - - - - - - - - - - - - - -

TIMES:
	ADD B			;A+=B 		
	DCR C			;C<-C-1. . .
	JNZ TIMES
	RET



	
	
	
	
	
	
	