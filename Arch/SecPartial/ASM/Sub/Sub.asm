.DEFINE
	NUM0 09H
	NUM1 05H
	NUM2 03H
	NUM3 01H
 
.ORG 100H
	MVI A, NUM0
	STA 1100H	;STORES NUM0 IN DIR 1100H = 09H

	MVI A, NUM1
	STA 1101H	;. . .

	MVI A, NUM2
	STA 1105H	
	
	MVI A, NUM3
	STA 1106H	

	LDA 1101H	;LOAD NUM1 STORED IN DIR 1101H = 05H, IN A
	MOV B, A	;MOVE A DATA = NUM1 TO B
	
	LDA 1106H 	;LOAD NUM3 STORED IN DIR 1106H = 01H, IN A
	MOV C, A	;MOVE A DATA = NUM3 TO C

	LDA 1100H	;LOAD NUM0 STORED IN DIR 1100H = 09H, IN A
	SUB B		;09H - 05H
	MOV B, A	;MOVE A DATA = 04H, TO B

	LDA 1105H	;LOAD NUM2 STORED IN DIR 1105H = 03H, IN A
	SUB C		;03H - 01H
	MOV C, A	;MOVE A DATA = 02H, TO C

	HLT